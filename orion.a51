ORG 0000H
	L1: MOV A,#01H
	MOV P1,A
	ACALL DELAY
	MOV A,#02H
	MOV P1,A
	ACALL DELAY
	MOV A,#03H
	MOV P1,A
	ACALL DELAY
	MOV A,00H
	MOV P1,A
	SJMP L1
	
	DELAY: MOV R4,#10
	REP: MOV R1,#04
	HERE1: MOV R2,#255
	HERE2: MOV R3,#255
	HERE3: NOP
	NOP
	DJNZ R3,HERE3
	DJNZ R2,HERE2
	DJNZ R1,HERE1
	DJNZ R4,REP
	RET 
	END